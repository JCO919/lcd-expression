# Keil uVision project lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lcd-keil
  group Source Group 1
    ./: STARTUP.A51 LCD1602.c LCD1602.h main.c
